HEC-RAS study LNGDRN.prj: LNGDRN

--- LNGDRN.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,10673   ,230.2,241.8,249.7
XS GIS Cut Line= 3
 1686372.8254944429702.2123746521686768.06548746429837.426056488
1686865.15083663429883.109125862
#Sta/Elev= 30
       0 1019.97    54.2 1008.84    66.9 1004.87    79.6 1003.84   109.2  995.02
   130.4  985.79     143  982.91   155.7  981.88   244.4   980.1     277976.8428
   286.7  973.94   295.2  973.08   307.9  973.36   312.1  974.25   316.3  976.81
   316.3  976.84   320.5  981.27   325.7   984.9   338.3   986.7   358.6  986.75
   365.6  992.44   375.5 1003.27   391.9 1018.87   435.5 1064.09   439.9 1066.93
   453.1 1067.97   457.6 1070.04   486.2 1095.18   501.8 1102.19     525 1110.34
#Mann= 4 ,-1,0
       0     .05       0     277    .045       0   316.3     .06       0
     400      .1       0
Bank Sta=277,316.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10431   ,36.7,37.4,37.5
XS GIS Cut Line= 3
1686457.01296716429837.0490508951686461.75644385429918.636850018
1686653.68538313430138.355103132
#Sta/Elev= 30
       0  990.22    19.5  986.19    31.5  984.27    51.7  982.42   103.6  981.01
   161.3  981.71   163.9  981.38     167  980.11   175.5     975   181.1  973.12
   189.6  971.97   194.8  971.81   206.4  972.31   211.7  974.89   220.8  981.73
   225.2  983.28   240.7   984.3   255.6  982.85   260.5  986.03   275.5  998.45
   280.8  1001.3   291.7 1005.92   297.4 1008.82     303 1012.97   317.9 1021.77
   325.7 1025.29   333.9 1027.88   354.1 1039.57   362.6 1045.71   373.5 1052.59
#Mann= 5 ,-1,0
       0     .05       0  101.73     .06       0   175.5    .045       0
   211.7     .06       0  241.73      .1       0
#XS Ineff= 2 , 0
                          236.95         1019.32
Permanent Ineff=
       F       F
Bank Sta=175.5,211.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10394   ,389.3,389.2,388.6
XS GIS Cut Line= 3
1686425.34808582429851.5777602761686421.35114318429924.584648958
1686615.73177116430156.287931563
#Sta/Elev= 30
       0  995.24      53  986.66    77.9  982.14    99.2  980.92     167  981.01
   172.3  980.32     177  978.64   182.9  975.75   189.4  974.66   208.8  971.75
     214  971.56   220.6  971.92   224.5  973.19   226.8  974.66     234  980.54
   239.7  982.77   251.1  983.87   257.9  983.91   268.1  983.16   271.5  983.77
   276.6  987.66     289  999.84   302.2 1009.59   320.1 1025.56   333.4 1036.17
     345 1044.81   350.5 1048.43   360.2 1056.01   364.6 1058.52   375.6 1062.71
#Mann= 5 ,-1,0
       0     .05       0  123.12     .06       0   189.4    .045       0
   226.8     .06       0  273.12      .1       0
#XS Ineff= 2 , 0
                          257.37         1007.22
Permanent Ineff=
       F       F
Bank Sta=189.4,226.8
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10005   ,509.7,508.6,507
XS GIS Cut Line= 2
1686053.88602514430098.1149075791686325.16627512430409.834449473
#Sta/Elev= 30
       0 1024.06    11.8 1020.72      43 1010.55    58.2 1006.75      77 1000.59
     104  989.79   119.9  984.44   137.4  980.87   146.4  980.08   170.6  979.11
   210.3  979.29   215.3   977.4   222.7  973.52   227.3  971.55   231.2   970.7
   253.2  971.47   258.5  972.29  261.93  973.53   269.8  979.34   273.6  981.56
   286.8  983.48     302   983.2   306.7  984.76   310.8  987.89   326.5 1001.97
   337.9 1009.89   366.2 1033.35   397.4 1056.78   405.5 1061.65   413.2 1065.61
#Mann= 7 ,-1,0
       0      .1       0      10     .05       0      50      .1       0
     160     .05       0     180     .06       0   222.7    .045       0
  261.93     .06       0
Bank Sta=222.7,261.93
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9496    ,521.6,502,488.5
XS GIS Cut Line= 3
1685659.16813923430514.6819376651685738.21613785430523.002779624
1685954.55802878430739.344670562
#Sta/Elev= 30
       0 1024.14    25.1 1008.44    45.2  998.51    53.2  995.11    61.3  992.41
    77.4  989.38      93  987.91   104.5  982.24   107.4  981.71   144.1  978.71
   189.4  976.68  204.96  972.69     212  970.56   217.4  970.36   240.3  970.72
   245.7  972.69   257.5  979.94   262.9  984.21   268.6  987.87   285.8  994.85
   297.1  995.36   314.1  994.26   316.7  996.13   325.2 1004.79   330.8 1013.43
   333.6 1016.77   336.7 1019.47   339.3 1020.58   353.4 1025.61   385.4 1028.55
#Mann= 4 ,-1,0
       0      .1       0  204.96    .045       0   245.7      .1       0
  249.48     .06       0
Bank Sta=204.96,245.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8994    ,528.4,498.8,476.3
XS GIS Cut Line= 3
1685320.25378081430977.4922102231685725.15219118431000.239311929
1685847.98654039430962.327475753
#Sta/Elev= 30
       0  1103.5    11.9 1098.14    19.9 1096.26    23.9 1094.16    40.7 1083.58
    55.9 1070.23      76 1059.82      88 1052.25     100 1043.43   132.5 1024.33
   145.2 1014.82   156.1 1005.07   172.1  994.28   184.2  982.08   188.2  975.23
  191.09  971.43   192.2  970.14   196.2  969.25   220.2   968.9   232.2  969.63
   237.9  971.43   244.2  974.21   260.3  977.59   296.3  980.33   325.2     984
   376.5  987.32   404.5  990.81   425.4  994.62   492.4 1001.11   534.1 1007.25
#Mann= 4 ,-1,0
       0      .1       0  191.09    .045       0   237.9      .1       0
  445.54     .06       0
Bank Sta=191.09,237.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8495    ,289.2,268.1,244.6
XS GIS Cut Line= 3
1685816.83671199431420.5030128941685899.21304738431199.584658878
1685942.27340452431102.230807956
#Sta/Elev= 30
       0 1030.16     4.2 1028.73     8.5  1026.8    12.8 1024.46      17 1021.28
    25.6 1012.74    38.4 1001.47    46.1  993.87    49.2  989.55    55.5  979.88
    64.7  971.68    67.8  969.67    69.2  969.22      74  968.13    81.1  967.57
    93.9  967.67   100.4969.2029   106.7  971.25     111  972.12   136.6  973.56
   167.3  978.48   176.7  980.24   204.6  986.54   226.2  990.17   274.1  997.08
   323.7 1003.73     327 1003.92     331 1003.01   335.8 1000.86   342.2  997.41
#Mann= 3 ,-1,0
       0      .1       0    69.2    .045       0   100.4      .1       0
Bank Sta=69.2,100.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8227    ,47.4,48.8,53.2
XS GIS Cut Line= 2
1686174.48072382431608.7674237511686018.89468828431261.544929805
#Sta/Elev= 30
       0   987.3    15.6  987.88    44.9  987.65    54.7   986.9    70.4  984.55
   101.1  982.07     114  982.56   138.2  982.35   141.2  981.93   144.9  980.57
   159.4   972.6   162.4  970.65   166.8  968.58   171.2  967.51   184.3  966.99
   206.3  967.22   210.6   967.9   219.4  970.03  223.45  970.64   228.2  972.01
   236.9  975.73   241.1  977.17   245.7  978.22   250.3  978.88   269.9  980.29
   292.5   980.8   337.8  982.98   364.1  983.68   374.3  984.76   380.5  985.72
#Mann= 7 ,-1,0
       0     .06       0      60     .05       0     110     .06       0
   162.4    .045       0  223.45     .07       0     300      .1       0
     330     .06       0
Bank Sta=162.4,223.45
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8179    ,165.4,186.3,205.8
XS GIS Cut Line= 2
1686209.58245135431603.0752517191686073.91901792431253.006671758
#Sta/Elev= 30
       0     985    58.5   982.2     110  980.69   118.5  980.45   131.4  978.95
     136  976.48   144.3  970.33   149.9969.0173   157.2  968.43   165.7  967.21
   185.5   967.1   195.8  967.21   204.3  968.96   208.6  970.11   216.4  972.89
   221.5  975.31   225.8  977.81   230.1  979.49   238.7   980.2   255.8  980.67
   264.4  980.51   269.7  981.29   293.7  982.65   299.9  982.72   309.2  984.15
   330.8  988.29   336.2  989.78   347.2  992.05   364.8   995.3   375.4  997.99
#Mann= 6 ,-1,0
       0     .06       0     110      .1       0   149.9    .045       0
   204.3     .06       0     210     .07       0     320      .1       0
Bank Sta=149.9,204.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7992    ,457.5,494,523.7
XS GIS Cut Line= 2
1686261.41050633431617.6720463591686381.21190865431352.289193124
#Sta/Elev= 30
       0  979.66    18.8  979.05    67.1  979.37    80.2  978.04      89  976.02
   106.6  975.72     111   974.7   119.7  970.53   135.5968.4136     148  966.35
   154.8  966.04   178.3  966.34   181.2  966.65   184.3  968.46   185.6  969.44
     190  974.51   191.3  975.37   194.3  977.13   202.5  979.92   207.5  982.31
   211.9  985.32   220.7   992.8   238.2 1005.63     247 1012.95   251.4  1017.8
   260.2 1028.96   264.6 1033.94   273.3 1042.52   282.1 1052.89   291.2 1061.76
#Mann= 3 ,-1,0
       0      .1       0   135.5    .045       0   184.3      .1       0
Bank Sta=135.5,184.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7498    ,500,500.8,499.2
XS GIS Cut Line= 4
1686252.31166565431855.7583775471686322.06944422431857.274850994
1686579.86993022431917.9337888761686660.24302291431904.285527852
#Sta/Elev= 30
       0  993.19    11.8  992.82    19.8   990.5      28  988.75    47.8  981.51
    67.8  978.02   104.7  974.58   154.1  974.06   158.2  973.45   166.4  971.24
   177.3  969.69   186.9  967.67   195.2  966.72   203.4   964.8   207.2  964.72
   236.2  964.74   240.4  965.62   241.7966.6762   244.5  968.88   252.7  978.29
   263.8  988.93   281.4 1008.92     302 1030.38   314.3 1041.73   322.5 1048.15
   334.6 1055.85   355.1 1066.55   367.3 1072.01   384.6 1078.09   416.1 1092.29
#Mann= 4 ,-1,0
       0     .06       0   99.77      .1       0   195.2    .045       0
   241.7      .1       0
Bank Sta=195.2,241.7
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6997    ,495.8,495.8,495.8
XS GIS Cut Line= 4
1685996.54463662432267.5054510581686065.33187218432314.182503759
 1686576.3227649432424.7334180491686701.61380109432439.473539955
#Sta/Elev= 30
       0    1009    47.8  1006.7      86 1001.67   110.5  999.73   216.9  999.16
   241.5  999.66   257.9 1001.13   286.5 1001.23   290.6 1000.63   294.7  998.32
   316.2  976.57   327.4  967.44   331.5  965.61   335.6  965.01     352  966.78
   364.3  964.43   372.5  962.94   380.6  962.82   419.4964.3966   433.8   967.7
   462.5  967.58     508  969.42   541.7   966.7   548.3  967.75   565.2  973.04
     638  978.22   658.1  982.19   682.3  989.17   718.5 1004.76   732.1 1009.32
#Mann= 7 ,-1,0
       0     .05       0  183.13     .06       0  283.13      .1       0
   364.3    .045       0   419.4      .1       0  483.13     .06       0
  583.13      .1       0
#XS Ineff= 2 , 0
                          501.51          973.09
Permanent Ineff=
       F       F
Bank Sta=364.3,419.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6502    ,38.5,38.5,38.5
XS GIS Cut Line= 6
1686459.68783763432926.523478805 1686513.0438169 432917.41392137
1686613.24894869432800.2910400551686600.23529521432726.113215222
1686529.96156642432670.1545052611686582.01618034432542.620701163
#Sta/Elev= 30
       0  971.29    28.8  971.55    54.1  969.45    76.3  968.75   139.5  967.96
   157.3  968.04   169.6  965.46   173.2  965.02   181.8  964.63   198.8  964.73
   204.5   963.7   207.3  962.76   212.1  961.78   236.4  961.66   260.7   962.1
   264.9  962.56   268.9  963.73     273  964.54   283.7  965.35   301.9  965.34
   318.2  965.93   343.9  966.09   373.4  965.89   391.6  968.24   418.4  970.04
     432  970.63   453.2  969.67   463.8  969.99     485  972.64   511.2  973.54
#Mann= 5 ,-1,0
       0     .05       0  104.13     .06       0   204.5    .045       0
   268.9     .05       0  343.58      .1       0
Bank Sta=204.5,268.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6463    ,525.3,692.8,797.5
XS GIS Cut Line= 6
1686455.78374159 432948.646689721686534.63932171432938.499619989
1686648.38581308432812.0033281871686643.18035169432749.537791485
1686567.77504002432674.6234745511686612.83183246432565.472450235
#Sta/Elev= 30
       0  970.06    16.5  969.95    69.7  967.56    87.5  967.51     109  968.01
   177.4  967.33   183.4  966.84   195.2  964.35     222  964.08   225.3  963.86
   232.1  962.68   248.9  962.62   257.1  961.69   261.1  961.63   277.2  962.02
   305.3  961.65   309.3  962.08   312.3  962.83   323.9  963.82   349.3  965.32
   366.3  965.92   391.1  965.12   430.2  965.63   440.7  966.37   451.3  968.32
     460   969.4   472.1   971.3   477.3  971.73   498.9  972.29   536.9   972.7
#Mann= 6 ,-1,0
       0     .05       0   99.51      .1       0  159.51     .06       0
   225.3    .045       0   323.9     .05       0  399.13      .1       0
Bank Sta=225.3,323.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5770    ,331.5,332.6,333.5
XS GIS Cut Line= 2
1686334.66508489432697.3546628591686244.58656214433110.896971872
#Sta/Elev= 30
       0   997.9    40.1   996.2    52.4  993.94    64.7  990.06    97.4  977.59
   105.6  975.35   113.8  972.36   126.1  969.98   142.4  968.13   199.8  966.87
   207.9  965.34   220.2  964.75   224.3  963.71   235.7958.9493   240.7  957.22
   256.9  956.44   265.3  956.53   277.1  958.03   280.5  958.93   285.7   960.7
   307.4  963.83   310.3  964.51   314.4  966.86   322.6  973.86   330.8  986.55
   363.5 1014.67     384 1036.68   391.4 1042.34   408.5 1053.09   423.2 1058.83
#Mann= 5 ,-1,0
       0      .1       0     100     .05       0   235.7    .045       0
   280.5     .05       0     300      .1       0
Bank Sta=235.7,280.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5438    ,217.8,236.4,265.3
XS GIS Cut Line= 3
1686073.98329934432626.3837055371686008.47164643432682.341575734
1685921.12277588433020.818449117
#Sta/Elev= 30
       0  994.77    34.1  989.13    51.1  985.03    64.9  979.58    77.2  971.93
    85.1  969.75    96.7  968.81   109.1  964.63   113.2  963.76   154.5  963.55
   220.6  961.92   224.7  961.19     233  957.22   237.1  955.96   245.4  954.71
   253.7  954.46   275.4  955.95   290.8  960.31   307.4  962.09   311.5  963.47
   315.6  966.08   328.1  976.09   332.2  978.66   361.1  987.43   370.6  993.38
   378.2  997.49   398.3 1006.11   410.6  1013.5     423 1019.81   435.7 1024.71
#Mann= 3 ,-1,0
       0      .1       0   237.1    .045       0   275.4      .1       0
Bank Sta=237.1,275.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5201    ,44.5,50.2,43.7
XS GIS Cut Line= 5
1685939.14169845432629.8121794751685780.37512601432761.250079617
1685650.23859121432838.0306351451685462.84198111432825.016981666
1685425.10238602432884.879787671
#Sta/Elev= 30
       0  974.64     112  968.02   175.3  965.26   211.1   965.1   217.5  963.63
   229.6  955.77   236.2     954     270  953.83   285.4  953.91   296.3  955.68
   299.3  956.39     308  962.87   314.9  965.74   387.4  965.67     401  968.04
   415.5  973.35   419.5  973.72   423.5  972.77   431.8  968.49   439.3  967.24
   471.6  966.57   487.2  969.28   503.7  977.93   508.7  979.26   515.7  980.31
   531.8  980.38   545.1  978.11   553.9  986.85   572.8 1000.78   615.8 1027.61
#Mann= 4 ,-1,0
       0     .06       0   229.6    .045       0   296.3     .06       0
  545.06      .1       0
Bank Sta=229.6,296.3
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5151    ,712.1,674.5,632.9
XS GIS Cut Line= 5
1685917.01848754432606.3876032121685776.47102996432720.907753831
 1685628.1153803432804.1951360991685431.60921276432791.181482619
1685387.36279093432867.962038148
#Sta/Elev= 30
       0  974.64    10.7  973.48   101.7  968.38   145.6  966.64   164.2  965.28
   196.9  964.35   213.8  961.03   225.4   959.6   244.9955.4069   262.2  953.82
   291.8  953.77   303.1  954.04   307.6  955.43   319.4   962.6   333.1   964.3
   371.5  964.24   423.6  962.56   431.6  962.58   443.6  963.65   459.7   962.5
   495.7  964.56   515.8  964.53   546.6  965.75   554.6  966.81   568.4  966.21
     573  967.81   581.2  978.54   591.5  987.87   628.4 1012.63     637 1017.62
#Mann= 8 ,-1,0
       0     .06       0      80     .05       0     140     .06       0
   201.3      .1       0   244.9    .045       0   307.6      .1       0
   321.3     .06       0  521.43      .1       0
Bank Sta=244.9,307.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4477    ,489.3,477.9,462.4
XS GIS Cut Line= 3
 1685007.7466583432396.1406531411685043.36861957432474.754636636
1685169.88799926432813.777440461
#Sta/Elev= 30
       0  1035.9    13.6    1031    22.4 1026.93    35.6 1021.92    48.7  1014.8
    57.5 1012.42    96.7  992.44   116.3   986.1   134.9  977.82   141.1  973.82
   152.3  963.98   159.8   955.1   165.1   952.5   173.6  950.82   200.2  950.61
   207.8  950.71   215.7  952.35   218.9  952.48   240.6  955.18   250.5  955.58
   263.3  956.97   284.6  957.18   318.8  956.16   371.2  956.88   391.3   956.5
   395.6  957.25   405.4  962.76   411.6   964.7   438.3  967.38   448.2  967.61
#Mann= 4 ,-1,0
       0      .1       0   165.1    .045       0   218.9      .1       0
  316.31     .06       0
Bank Sta=165.1,218.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3999    ,606.7,581.9,558.4
XS GIS Cut Line= 2
1684597.43410686432768.4992037181684896.98441739433032.477914873
#Sta/Elev= 30
       0 1048.67    24.9  1031.2    54.5 1012.94    64.3 1006.01    81.3  991.41
    88.9  984.05    90.8  981.41    96.9  969.16    99.5  965.43  115.61   950.7
   120.9  948.26     138  947.99   152.9   948.2     172   950.7   181.6  951.47
   200.8  951.37   211.6  953.02   285.3  955.95     308  955.18   320.7  955.65
   339.5  958.81   344.8  960.47   350.5  963.66   353.3  964.33   363.1  964.95
     376  964.23   378.9  965.54   381.7  967.98     393  984.02   399.3  989.45
#Mann= 5 ,-1,0
       0      .1       0  115.61    .045       0     172      .1       0
     240     .06       0     370      .1       0
Bank Sta=115.61,172
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3417    ,331.9,317,307.4
XS GIS Cut Line= 4
1684221.30631733433496.4366820741684327.45945862433440.327164533
1684727.80844865433284.1303994861684808.18154134433255.317403992
#Sta/Elev= 30
       0 1133.38    16.8 1121.77    34.6 1114.37    48.4 1105.62    68.3 1098.77
   107.2 1074.44   120.8 1063.06   142.2 1048.42   172.3 1034.82   188.4 1024.08
   193.8 1019.35   215.2  992.71   223.8  985.38   232.4  972.06     244  960.83
   250.1  952.68   253.9  949.61   262.6  947.16   268.7  945.59   287.2   945.3
   302.6  947.07   336.6  951.86   482.7  952.17   521.9   954.2   537.3  959.28
   562.2  958.05   570.9  966.38   584.1  984.94   590.4  991.77   635.2 1017.58
#Mann= 6 ,-1,0
       0      .1       0   262.6    .045       0   302.6     .06       0
  390.07     .05       0  500.07     .06       0  609.81      .1       0
Bank Sta=262.6,302.6
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3100    ,286.6,272.9,264.8
XS GIS Cut Line= 4
1684547.34810845433775.4677963331684630.75414804433693.578230192
1684830.92864305433385.7341204391684858.22516509433353.888178051
#Sta/Elev= 30
       0  1089.5    15.6 1079.15    38.4 1066.15    79.6 1046.92    96.4 1034.72
     107  1025.6   122.9 1007.98     136  996.67   146.8  984.01   156.3  969.46
   161.1  963.45   170.7  955.79   180.2  949.82   189.7  947.21   208.8  948.27
   223.1  947.38     309  947.82   344.1  944.94   366.2  943.97   383.5  944.87
   390.4  948.74   394.9  949.92   442.6  950.92   462.7  955.44   480.7  955.58
   485.7   956.8   494.3  962.67   506.7  976.48     512  980.98     526  988.14
#Mann= 4 ,-1,0
       0      .1       0   344.1    .045       0   383.5      .1       0
  494.09     .06       0
Bank Sta=344.1,383.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2827    ,48.6,49.3,49.3
XS GIS Cut Line= 6
 1684978.0577523433806.8166700041685014.01274474433786.516797006
1684984.83090391433717.0243783391684983.04576626433577.783641523
1684892.00374603433452.8240059181684899.14429664433329.649507965
#Sta/Elev= 30
       0  972.76    16.1  965.55    34.5  954.76    39.1  953.06    90.1  953.08
   117.1  952.13   137.1  952.79   161.2  951.22   169.1  949.52   178.8 943.766
   185.2  942.16   201.2  942.08   217.2  943.75   229.2  943.22   237.2  945.93
   255.9   949.3   281.3  948.03   336.6  948.95   361.4  950.22     396  953.62
   438.9  955.09   442.9  957.17   450.9  964.45   454.9  966.98   466.9  971.13
   479.1  977.59   482.9  980.26   490.9  989.07   494.9   992.5   533.9  1014.8
#Mann= 6 ,-1,0
       0     .06       0   178.8    .045       0   217.2     .06       0
  275.91      .1       0  385.91     .06       0  490.52      .1       0
Bank Sta=178.8,217.2
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2778    ,278.4,320.1,356.4
XS GIS Cut Line= 6
1684991.41281486433824.8565351271685055.64320271433783.741433141
 1685025.8890699433717.0243783391685034.81475815433588.494467432
  1684974.120078433479.6010706911684993.75659217433340.360333874
#Sta/Elev= 30
       0  969.84     5.6   967.6    24.6   957.1    34.1   953.1    59.9  953.49
      76  952.16    94.7  952.05   177.9  952.47   181.9  951.93   185.6  950.02
   189.9  946.25   193.1  944.44   197.9  943.37     214  942.13   234.3  942.42
     246  944.44   253.1  946.54   256.8  946.95   283.7  946.75   315.4  948.71
   392.6  950.47   422.1  952.74   426.1  954.78   442.3  968.16   458.4  982.17
   466.5  988.66   474.6  994.31   482.7  999.23   526.3  1023.3   543.4 1031.65
#Mann= 4 ,-1,0
       0     .06       0   193.1    .045       0     246     .06       0
  512.82      .1       0
Bank Sta=193.1,246
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2458    ,263.7,267,270.8
XS GIS Cut Line= 4
1684932.39960985433890.4992307981685078.57248541433836.452117145
1685300.90265748433886.8142003211685400.39848034433884.357513337
#Sta/Elev= 30
       0  982.32    12.5  978.23    29.5  974.62    50.9  973.62    72.9  970.59
    82.3  966.25   100.9  953.04   106.3  950.52   110.6  949.74   144.7  953.22
   177.9  952.47   190.2  951.06   198.4  947.54   206.6  945.63   218.9  944.56
   239.5  945.61   257.5  942.03   272.3  940.58   292.8  940.91   298.4942.0176
     301  943.31   309.2  953.34   316.8  958.18   337.3  964.39   362.5  970.11
   374.8  975.27     395  992.77     435 1018.34     455 1033.57   483.3 1052.26
#Mann= 6 ,-1,0
       0      .1       0      50     .05       0      60     .06       0
     150      .1       0   257.5    .045       0   298.4      .1       0
#XS Ineff= 2 , 0
          162.47  1001.6
Permanent Ineff=
       F       F
Bank Sta=257.5,298.4
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2191    ,253.3,253.1,252.5
XS GIS Cut Line= 2
1684901.69102254434029.3020454071685275.10744415434182.844981922
#Sta/Elev= 30
       0  987.49    50.2  974.42    84.8   961.2    93.4  959.46   106.4  954.48
   119.4  952.02     128  951.89     141  950.51   171.3  950.99   184.3  949.81
   188.6  948.64  198.01  942.15   201.6  940.38   205.9  939.62   218.9  939.12
   237.3  939.28   240.5  939.79   246.5  942.15   253.5  944.87   262.1   946.8
     274  951.48   292.4  962.14   309.7   975.8   314.4  980.58     320  987.46
   326.1  993.44   331.3  996.75   344.3 1003.24   372.1 1022.93   403.8 1043.77
#Mann= 6 ,-1,0
       0      .1       0      80     .05       0     110     .06       0
  198.01    .045       0   246.5     .06       0     290      .1       0
Bank Sta=198.01,246.5
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1937    ,438.4,437.6,435.6
XS GIS Cut Line= 3
1684773.04510608434310.6852952711684888.29708805434300.069981141
1685146.09757405  434398.6407552
#Sta/Elev= 30
       0  990.85    47.3  973.04    79.4   959.4    91.5  955.55   119.8   951.6
   140.7   949.4   158.4  949.33   183.9  950.22   201.2  948.92   205.5  947.62
     214  940.86   218.3  939.04   221.3  938.67   239.7  938.16   252.3  938.82
   256.9  940.88   261.1  946.03   265.4   948.9     274  955.85   286.8   960.5
   291.1  962.62   304.9  971.05   316.8  977.12   333.9  983.53   338.2  984.78
   350.4  987.15   355.4  988.78   366.9  994.13   381.1  999.12   391.7 1003.81
#Mann= 5 ,-1,0
       0      .1       0     110     .06       0  205.74      .1       0
     214    .045       0   256.9      .1       0
Bank Sta=214,256.9
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1500    ,510.1,509.6,505.5
XS GIS Cut Line= 3
1684569.83766417434673.1224491171684706.32027441434698.902497717
1685036.91148587434805.055639011
#Sta/Elev= 30
       0 1044.68    30.8 1023.94    67.4  997.52    87.8  987.89   104.1  977.82
   120.4  969.04   141.6  955.88   149.2  953.02   174.4  953.02   195.4  950.52
   199.6  948.41   209.7  939.17   212.2  937.73   216.4  937.33   237.4  937.06
   245.8  937.51   254.2  939.21   258.4   940.5   262.6  942.96   266.8  943.91
   283.6  942.07   317.2  942.97   337.2  947.89   354.7  955.46   371.8  965.11
   401.3  974.06   413.9  978.65   443.3  995.56   468.5 1005.79   486.1 1015.53
#Mann= 5 ,-1,0
       0      .1       0     110     .06       0   209.7    .045       0
   254.2     .06       0   318.9      .1       0
Bank Sta=209.7,254.2
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,990     ,500.5,500.5,494.3
XS GIS Cut Line= 3
1684447.73139534435165.3287248281684580.84406458435190.603282279
 1684931.3179279435278.221748109
#Sta/Elev= 30
       0  1082.9    16.7 1075.62    45.2 1054.44    65.5 1044.47    73.7 1037.35
    85.9 1024.83   118.5  995.41   130.7  987.62   143.1  977.54   147.1  973.77
   155.4  961.71   159.3  957.64   171.8  948.87   179.4  945.97   196.6  948.29
   217.2  947.44   221.3  946.23   233.7  937.54   235.4  937.15   241.9  936.29
   262.6  937.12   281.6  936.14     290937.1387   307.7  944.74   328.5  951.18
   364.1  959.38   406.9  971.39   439.8  988.58   468.7  997.48   496.8 1011.32
#Mann= 5 ,-1,0
       0      .1       0  135.49     .06       0   262.6    .045       0
     290     .06       0  345.49      .1       0
Bank Sta=262.6,290
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,490     ,460.2,447.1,431.5
XS GIS Cut Line= 3
 1684207.2319068435642.6628060381684406.97777001435668.027360097
1684930.12169749435737.779883761
#Sta/Elev= 30
       0 1136.82    27.5 1113.74    49.7 1102.84    65.4 1090.34    91.9 1076.14
   117.8  1064.8     142 1042.25   162.2 1027.19   198.5 1011.51     263  954.46
   283.2  954.31     299  951.46   318.5  934.83   339.7  933.36     358934.8009
   367.9  935.44   384.1  939.51   464.8  939.13   472.9  940.08   481.5  943.06
   517.3  964.45   553.6  991.88   573.8 1001.31   614.1 1030.35   642.4  1045.3
   654.5 1048.81   674.6 1062.11   694.8 1078.07     711 1080.41   729.1 1087.79
#Mann= 5 ,-1,0
       0      .1       0  281.35     .06       0   318.5    .045       0
     358     .06       0  381.35      .1       0
Bank Sta=318.5,358
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43      ,,,
XS GIS Cut Line= 3
 1684363.5413123436157.6574258841684577.07885668436151.025825127
1684931.20633712435952.077802409
#Sta/Elev= 30
       0 1065.51    12.6 1056.22    28.6  1041.6    73.8 1020.67   128.6  973.61
   136.6  961.36   140.6  958.29   164.7  959.78   188.7  958.38   208.7  947.64
   226.3  944.08   238.3  939.54   258.4  938.14  266.66  933.82   284.1  931.21
   311.7  931.33   318.1  933.82   327.2  936.75   365.7  938.62   400.6  943.44
   414.4  953.88   447.4  972.92   463.7   989.1     497 1010.76   511.5    1018
   540.8 1036.13     552    1039   561.2 1044.69   588.8 1054.14   619.8  1073.7
#Mann= 5 ,-1,0
       0      .1       0      20     .06       0     120      .1       0
  266.66    .045       0   318.1      .1       0
Bank Sta=266.66,318.1
XS Rating Curve= 0 ,0
Exp/Cntr(USF)=0,0
Exp/Cntr=0.3,0.1
LCMann Table=0

Chan Stop Cuts=-1
Use User Specified Reach Order=0
Composite Channel Slope=5
